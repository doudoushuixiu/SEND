# IAR project project.ewp, settings and files
configuration stm8l10x (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101F3P STM8L101F3P
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8L10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8L101_EVAL; ..\..\..\Utilities\STM8L101_EVAL\Common
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: stm8l101-eval.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group User
    ../: main.c stm8l10x_it.c
    ../../../Libraries/STM8L10x_StdPeriph_Driver/src/: stm8l10x_awu.c stm8l10x_clk.c stm8l10x_gpio.c stm8l10x_spi.c stm8l10x_tim4.c
